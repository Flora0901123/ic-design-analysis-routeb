* Circuit, read from the shapes
.subckt routeb_new_1w1r_20x64_delay_chain gnd in out vdd
XM1 routeb_new_1w1r_20x64_pinv_14_1/A in gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM2 routeb_new_1w1r_20x64_pinv_14_10/A routeb_new_1w1r_20x64_pinv_14_1/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM3 routeb_new_1w1r_20x64_pinv_14_11/A routeb_new_1w1r_20x64_pinv_14_10/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM4 routeb_new_1w1r_20x64_pinv_14_16/A routeb_new_1w1r_20x64_pinv_14_11/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM5 routeb_new_1w1r_20x64_pinv_14_21/A routeb_new_1w1r_20x64_pinv_14_16/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM6 routeb_new_1w1r_20x64_pinv_14_26/A routeb_new_1w1r_20x64_pinv_14_21/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM7 routeb_new_1w1r_20x64_pinv_14_31/A routeb_new_1w1r_20x64_pinv_14_26/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM8 routeb_new_1w1r_20x64_pinv_14_36/A routeb_new_1w1r_20x64_pinv_14_31/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM9 out routeb_new_1w1r_20x64_pinv_14_36/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM10 routeb_new_1w1r_20x64_pinv_14_1/Z routeb_new_1w1r_20x64_pinv_14_1/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM11 routeb_new_1w1r_20x64_pinv_14_6/Z routeb_new_1w1r_20x64_pinv_14_10/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM12 routeb_new_1w1r_20x64_pinv_14_11/Z routeb_new_1w1r_20x64_pinv_14_11/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM13 routeb_new_1w1r_20x64_pinv_14_16/Z routeb_new_1w1r_20x64_pinv_14_16/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM14 routeb_new_1w1r_20x64_pinv_14_21/Z routeb_new_1w1r_20x64_pinv_14_21/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM15 routeb_new_1w1r_20x64_pinv_14_26/Z routeb_new_1w1r_20x64_pinv_14_26/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM16 routeb_new_1w1r_20x64_pinv_14_31/Z routeb_new_1w1r_20x64_pinv_14_31/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM17 routeb_new_1w1r_20x64_pinv_14_36/Z routeb_new_1w1r_20x64_pinv_14_36/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM18 routeb_new_1w1r_20x64_pinv_14_41/Z out gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM19 routeb_new_1w1r_20x64_pinv_14_2/Z routeb_new_1w1r_20x64_pinv_14_1/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM20 routeb_new_1w1r_20x64_pinv_14_7/Z routeb_new_1w1r_20x64_pinv_14_10/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM21 routeb_new_1w1r_20x64_pinv_14_12/Z routeb_new_1w1r_20x64_pinv_14_11/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM22 routeb_new_1w1r_20x64_pinv_14_17/Z routeb_new_1w1r_20x64_pinv_14_16/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM23 routeb_new_1w1r_20x64_pinv_14_22/Z routeb_new_1w1r_20x64_pinv_14_21/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM24 routeb_new_1w1r_20x64_pinv_14_27/Z routeb_new_1w1r_20x64_pinv_14_26/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM25 routeb_new_1w1r_20x64_pinv_14_32/Z routeb_new_1w1r_20x64_pinv_14_31/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM26 routeb_new_1w1r_20x64_pinv_14_37/Z routeb_new_1w1r_20x64_pinv_14_36/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM27 routeb_new_1w1r_20x64_pinv_14_42/Z out gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM28 routeb_new_1w1r_20x64_pinv_14_3/Z routeb_new_1w1r_20x64_pinv_14_1/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM29 routeb_new_1w1r_20x64_pinv_14_8/Z routeb_new_1w1r_20x64_pinv_14_10/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM30 routeb_new_1w1r_20x64_pinv_14_13/Z routeb_new_1w1r_20x64_pinv_14_11/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM31 routeb_new_1w1r_20x64_pinv_14_18/Z routeb_new_1w1r_20x64_pinv_14_16/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM32 routeb_new_1w1r_20x64_pinv_14_23/Z routeb_new_1w1r_20x64_pinv_14_21/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM33 routeb_new_1w1r_20x64_pinv_14_28/Z routeb_new_1w1r_20x64_pinv_14_26/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM34 routeb_new_1w1r_20x64_pinv_14_33/Z routeb_new_1w1r_20x64_pinv_14_31/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM35 routeb_new_1w1r_20x64_pinv_14_38/Z routeb_new_1w1r_20x64_pinv_14_36/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM36 routeb_new_1w1r_20x64_pinv_14_43/Z out gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM37 routeb_new_1w1r_20x64_pinv_14_4/Z routeb_new_1w1r_20x64_pinv_14_1/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM38 routeb_new_1w1r_20x64_pinv_14_9/Z routeb_new_1w1r_20x64_pinv_14_10/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM39 routeb_new_1w1r_20x64_pinv_14_14/Z routeb_new_1w1r_20x64_pinv_14_11/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM40 routeb_new_1w1r_20x64_pinv_14_19/Z routeb_new_1w1r_20x64_pinv_14_16/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM41 routeb_new_1w1r_20x64_pinv_14_24/Z routeb_new_1w1r_20x64_pinv_14_21/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM42 routeb_new_1w1r_20x64_pinv_14_29/Z routeb_new_1w1r_20x64_pinv_14_26/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM43 routeb_new_1w1r_20x64_pinv_14_34/Z routeb_new_1w1r_20x64_pinv_14_31/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM44 routeb_new_1w1r_20x64_pinv_14_39/Z routeb_new_1w1r_20x64_pinv_14_36/A gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM45 routeb_new_1w1r_20x64_pinv_14_44/Z out gnd gnd sky130_fd_pr__nfet_01v8 w=0.36 l=0.15
XM46 routeb_new_1w1r_20x64_pinv_14_1/A in vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM47 routeb_new_1w1r_20x64_pinv_14_10/A routeb_new_1w1r_20x64_pinv_14_1/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM48 routeb_new_1w1r_20x64_pinv_14_11/A routeb_new_1w1r_20x64_pinv_14_10/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM49 routeb_new_1w1r_20x64_pinv_14_16/A routeb_new_1w1r_20x64_pinv_14_11/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM50 routeb_new_1w1r_20x64_pinv_14_21/A routeb_new_1w1r_20x64_pinv_14_16/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM51 routeb_new_1w1r_20x64_pinv_14_26/A routeb_new_1w1r_20x64_pinv_14_21/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM52 routeb_new_1w1r_20x64_pinv_14_31/A routeb_new_1w1r_20x64_pinv_14_26/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM53 routeb_new_1w1r_20x64_pinv_14_36/A routeb_new_1w1r_20x64_pinv_14_31/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM54 out routeb_new_1w1r_20x64_pinv_14_36/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM55 routeb_new_1w1r_20x64_pinv_14_1/Z routeb_new_1w1r_20x64_pinv_14_1/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM56 routeb_new_1w1r_20x64_pinv_14_6/Z routeb_new_1w1r_20x64_pinv_14_10/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM57 routeb_new_1w1r_20x64_pinv_14_11/Z routeb_new_1w1r_20x64_pinv_14_11/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM58 routeb_new_1w1r_20x64_pinv_14_16/Z routeb_new_1w1r_20x64_pinv_14_16/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM59 routeb_new_1w1r_20x64_pinv_14_21/Z routeb_new_1w1r_20x64_pinv_14_21/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM60 routeb_new_1w1r_20x64_pinv_14_26/Z routeb_new_1w1r_20x64_pinv_14_26/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM61 routeb_new_1w1r_20x64_pinv_14_31/Z routeb_new_1w1r_20x64_pinv_14_31/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM62 routeb_new_1w1r_20x64_pinv_14_36/Z routeb_new_1w1r_20x64_pinv_14_36/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM63 routeb_new_1w1r_20x64_pinv_14_41/Z out vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM64 routeb_new_1w1r_20x64_pinv_14_2/Z routeb_new_1w1r_20x64_pinv_14_1/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM65 routeb_new_1w1r_20x64_pinv_14_7/Z routeb_new_1w1r_20x64_pinv_14_10/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM66 routeb_new_1w1r_20x64_pinv_14_12/Z routeb_new_1w1r_20x64_pinv_14_11/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM67 routeb_new_1w1r_20x64_pinv_14_17/Z routeb_new_1w1r_20x64_pinv_14_16/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM68 routeb_new_1w1r_20x64_pinv_14_22/Z routeb_new_1w1r_20x64_pinv_14_21/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM69 routeb_new_1w1r_20x64_pinv_14_27/Z routeb_new_1w1r_20x64_pinv_14_26/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM70 routeb_new_1w1r_20x64_pinv_14_32/Z routeb_new_1w1r_20x64_pinv_14_31/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM71 routeb_new_1w1r_20x64_pinv_14_37/Z routeb_new_1w1r_20x64_pinv_14_36/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM72 routeb_new_1w1r_20x64_pinv_14_42/Z out vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM73 routeb_new_1w1r_20x64_pinv_14_3/Z routeb_new_1w1r_20x64_pinv_14_1/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM74 routeb_new_1w1r_20x64_pinv_14_8/Z routeb_new_1w1r_20x64_pinv_14_10/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM75 routeb_new_1w1r_20x64_pinv_14_13/Z routeb_new_1w1r_20x64_pinv_14_11/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM76 routeb_new_1w1r_20x64_pinv_14_18/Z routeb_new_1w1r_20x64_pinv_14_16/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM77 routeb_new_1w1r_20x64_pinv_14_23/Z routeb_new_1w1r_20x64_pinv_14_21/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM78 routeb_new_1w1r_20x64_pinv_14_28/Z routeb_new_1w1r_20x64_pinv_14_26/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM79 routeb_new_1w1r_20x64_pinv_14_33/Z routeb_new_1w1r_20x64_pinv_14_31/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM80 routeb_new_1w1r_20x64_pinv_14_38/Z routeb_new_1w1r_20x64_pinv_14_36/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM81 routeb_new_1w1r_20x64_pinv_14_43/Z out vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM82 routeb_new_1w1r_20x64_pinv_14_4/Z routeb_new_1w1r_20x64_pinv_14_1/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM83 routeb_new_1w1r_20x64_pinv_14_9/Z routeb_new_1w1r_20x64_pinv_14_10/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM84 routeb_new_1w1r_20x64_pinv_14_14/Z routeb_new_1w1r_20x64_pinv_14_11/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM85 routeb_new_1w1r_20x64_pinv_14_19/Z routeb_new_1w1r_20x64_pinv_14_16/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM86 routeb_new_1w1r_20x64_pinv_14_24/Z routeb_new_1w1r_20x64_pinv_14_21/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM87 routeb_new_1w1r_20x64_pinv_14_29/Z routeb_new_1w1r_20x64_pinv_14_26/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM88 routeb_new_1w1r_20x64_pinv_14_34/Z routeb_new_1w1r_20x64_pinv_14_31/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM89 routeb_new_1w1r_20x64_pinv_14_39/Z routeb_new_1w1r_20x64_pinv_14_36/A vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
XM90 routeb_new_1w1r_20x64_pinv_14_44/Z out vdd vdd sky130_fd_pr__pfet_01v8 w=1.12 l=0.15
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
nwell = (64, 20)
diff = (65, 20)
tap = (65, 44)
poly = (66, 20)
licon = (66, 44)
li1 = (67, 20)
mcon = (67, 44)
met1_5 = (68, 5)
met1 = (68, 20)
via = (68, 44)
met2_5 = (69, 5)
met2 = (69, 20)
via2 = (69, 44)
met3 = (70, 20)
via3 = (70, 44)
met4_5 = (71, 5)
met4 = (71, 20)
stdcell_id = (81, 4)
nsdm = (93, 44)
psdm = (94, 20)
npc = (95, 20)
boundary = (235, 4)

routeb_new_1w1r_20x64_co = lib.new_cell('routeb_new_1w1r_20x64_contact_11')
R(routeb_new_1w1r_20x64_co, nwell, [(-0.295,-0.255,0.545,0.585)])
R(routeb_new_1w1r_20x64_co, diff, [(0,0.02,0.25,0.31)])
R(routeb_new_1w1r_20x64_co, licon, [(0.04,0.08,0.21,0.25)])
R(routeb_new_1w1r_20x64_co, li1, [(0.04,0,0.21,0.33)])
R(routeb_new_1w1r_20x64_co, stdcell_id, [(-0.295,-0.255,0.545,0.585)])
R(routeb_new_1w1r_20x64_co, psdm, [(-0.125,-0.105,0.375,0.435)])
R(routeb_new_1w1r_20x64_co, boundary, [(-0.295,-0.255,0.545,0.585)])

routeb_new_1w1r_20x64_pm = lib.new_cell('routeb_new_1w1r_20x64_pmos_m1_w1_120_sli_dli_da_p')
R(routeb_new_1w1r_20x64_pm, nwell, [(-0.27,-0.27,1.02,1.39)])
R(routeb_new_1w1r_20x64_pm, diff, [(0,0,0.75,1.12)])
R(routeb_new_1w1r_20x64_pm, poly, [(0.3,-0.13,0.45,1.25), (0.3,-0.13,0.45,1.25)])
R(routeb_new_1w1r_20x64_pm, li1, [(0.04,0.395,0.21,0.725), (0.54,0.395,0.71,0.725)])
R(routeb_new_1w1r_20x64_pm, stdcell_id, [(-0.27,-0.27,1.02,1.39)])
R(routeb_new_1w1r_20x64_pm, psdm, [(-0.125,-0.125,0.875,1.245)])
R(routeb_new_1w1r_20x64_pm, boundary, [(-0.27,-0.27,1.02,1.39)])
routeb_new_1w1r_20x64_pm.add(gdstk.Reference(routeb_new_1w1r_20x64_co, (0,0.395)))
routeb_new_1w1r_20x64_pm.add(gdstk.Reference(routeb_new_1w1r_20x64_co, (0.5,0.395)))
routeb_new_1w1r_20x64_pm.add(gdstk.Label('G', (0.375,0.56), layer=66, texttype=5))
routeb_new_1w1r_20x64_pm.add(gdstk.Label('S', (0.125,0.56), layer=67, texttype=5))
routeb_new_1w1r_20x64_pm.add(gdstk.Label('D', (0.625,0.56), layer=67, texttype=5))

c_routeb_new_1w1r_20x64_co = lib.new_cell('routeb_new_1w1r_20x64_contact_10')
R(c_routeb_new_1w1r_20x64_co, diff, [(0,0.02,0.25,0.31)])
R(c_routeb_new_1w1r_20x64_co, licon, [(0.04,0.08,0.21,0.25)])
R(c_routeb_new_1w1r_20x64_co, li1, [(0.04,0,0.21,0.33)])
R(c_routeb_new_1w1r_20x64_co, stdcell_id, [(-0.125,-0.105,0.375,0.435)])
R(c_routeb_new_1w1r_20x64_co, nsdm, [(-0.125,-0.105,0.375,0.435)])
R(c_routeb_new_1w1r_20x64_co, boundary, [(-0.125,-0.105,0.375,0.435)])

routeb_new_1w1r_20x64_nm = lib.new_cell('routeb_new_1w1r_20x64_nmos_m1_w0_360_sli_dli_da_p')
R(routeb_new_1w1r_20x64_nm, diff, [(0,0,0.75,0.36)])
R(routeb_new_1w1r_20x64_nm, poly, [(0.3,-0.13,0.45,0.49), (0.3,-0.13,0.45,0.49)])
R(routeb_new_1w1r_20x64_nm, li1, [(0.04,0.015,0.21,0.345), (0.54,0.015,0.71,0.345)])
R(routeb_new_1w1r_20x64_nm, stdcell_id, [(-0.125,-0.13,0.875,0.49)])
R(routeb_new_1w1r_20x64_nm, nsdm, [(-0.125,-0.125,0.875,0.485)])
R(routeb_new_1w1r_20x64_nm, boundary, [(-0.125,-0.13,0.875,0.49)])
routeb_new_1w1r_20x64_nm.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co, (0,0.015)))
routeb_new_1w1r_20x64_nm.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co, (0.5,0.015)))
routeb_new_1w1r_20x64_nm.add(gdstk.Label('G', (0.375,0.18), layer=66, texttype=5))
routeb_new_1w1r_20x64_nm.add(gdstk.Label('S', (0.125,0.18), layer=67, texttype=5))
routeb_new_1w1r_20x64_nm.add(gdstk.Label('D', (0.625,0.18), layer=67, texttype=5))

c_routeb_new_1w1r_20x64_co_ = lib.new_cell('routeb_new_1w1r_20x64_contact_24')
R(c_routeb_new_1w1r_20x64_co_, nwell, [(-0.295,-0.215,0.545,0.625)])
R(c_routeb_new_1w1r_20x64_co_, tap, [(0,0,0.25,0.41)])
R(c_routeb_new_1w1r_20x64_co_, licon, [(0.04,0.12,0.21,0.29)])
R(c_routeb_new_1w1r_20x64_co_, li1, [(0.04,0.04,0.21,0.37)])
R(c_routeb_new_1w1r_20x64_co_, stdcell_id, [(-0.295,-0.215,0.545,0.625)])
R(c_routeb_new_1w1r_20x64_co_, nsdm, [(-0.125,-0.125,0.375,0.535)])
R(c_routeb_new_1w1r_20x64_co_, boundary, [(-0.295,-0.215,0.545,0.625)])

c_routeb_new_1w1r_20x64_co__ = lib.new_cell('routeb_new_1w1r_20x64_contact_25')
R(c_routeb_new_1w1r_20x64_co__, tap, [(0,0,0.25,0.41)])
R(c_routeb_new_1w1r_20x64_co__, licon, [(0.04,0.12,0.21,0.29)])
R(c_routeb_new_1w1r_20x64_co__, li1, [(0.04,0.04,0.21,0.37)])
R(c_routeb_new_1w1r_20x64_co__, stdcell_id, [(-0.125,-0.125,0.375,0.535)])
R(c_routeb_new_1w1r_20x64_co__, psdm, [(-0.125,-0.125,0.375,0.535)])
R(c_routeb_new_1w1r_20x64_co__, boundary, [(-0.125,-0.125,0.375,0.535)])

c_routeb_new_1w1r_20x64_co___ = lib.new_cell('routeb_new_1w1r_20x64_contact_15')
R(c_routeb_new_1w1r_20x64_co___, poly, [(0,0,0.33,0.33)])
R(c_routeb_new_1w1r_20x64_co___, licon, [(0.08,0.08,0.25,0.25)])
R(c_routeb_new_1w1r_20x64_co___, li1, [(0.08,0,0.25,0.33)])
R(c_routeb_new_1w1r_20x64_co___, stdcell_id, [(-0.1,-0.1,0.43,0.43)])
R(c_routeb_new_1w1r_20x64_co___, npc, [(-0.1,-0.1,0.43,0.43)])
R(c_routeb_new_1w1r_20x64_co___, boundary, [(-0.1,-0.1,0.43,0.43)])

routeb_new_1w1r_20x64_pi = lib.new_cell('routeb_new_1w1r_20x64_pinv_14')
R(routeb_new_1w1r_20x64_pi, nwell, [(-0.18,3.395,2.02,7.355)])
R(routeb_new_1w1r_20x64_pi, poly, [(0.57,0.745,0.72,5.565), (0.405,3.18,0.57,3.51)])
R(routeb_new_1w1r_20x64_pi, li1, [(0,-0.085,1.84,0.085), (0.31,-0.085,0.48,0.27), (1.33,0,1.5,0.46), (0.81,0.27,0.98,6.42), (0.32,3.18,0.49,3.51), (0.895,3.26,1.065,3.43), (0.31,6.09,0.48,7.155), (1.33,6.545,1.5,7.07), (0,6.985,1.84,7.155)])
R(routeb_new_1w1r_20x64_pi, stdcell_id, [(0,0,1.84,7.07), (0,0,1.84,7.07)])
R(routeb_new_1w1r_20x64_pi, nsdm, [(0,-0.19,1.84,0.19), (0,0,1.145,0.74)])
R(routeb_new_1w1r_20x64_pi, psdm, [(0,5.57,1.145,7.07), (0,6.88,1.84,7.26)])
R(routeb_new_1w1r_20x64_pi, boundary, [(0,0,1.84,7.07), (0,0,1.84,7.07)])
routeb_new_1w1r_20x64_pi.add(gdstk.Reference(routeb_new_1w1r_20x64_pm, (0.27,5.695)))
routeb_new_1w1r_20x64_pi.add(gdstk.Reference(routeb_new_1w1r_20x64_nm, (0.27,0.255)))
routeb_new_1w1r_20x64_pi.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_, (1.29,6.34)))
routeb_new_1w1r_20x64_pi.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co__, (1.29,0.255)))
routeb_new_1w1r_20x64_pi.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co___, (0.24,3.18)))
routeb_new_1w1r_20x64_pi.add(gdstk.Label('A', (0.405,3.345), layer=67, texttype=5))
routeb_new_1w1r_20x64_pi.add(gdstk.Label('Z', (0.98,3.345), layer=67, texttype=5))
routeb_new_1w1r_20x64_pi.add(gdstk.Label('gnd', (0.92,0), layer=67, texttype=5))
routeb_new_1w1r_20x64_pi.add(gdstk.Label('vdd', (0.92,7.07), layer=67, texttype=5))

c_routeb_new_1w1r_20x64_co____ = lib.new_cell('routeb_new_1w1r_20x64_contact_13')
R(c_routeb_new_1w1r_20x64_co____, li1, [(0.06,0,0.23,0.33)])
R(c_routeb_new_1w1r_20x64_co____, mcon, [(0.06,0.08,0.23,0.25)])
R(c_routeb_new_1w1r_20x64_co____, met1, [(0,0.05,0.29,0.28)])
R(c_routeb_new_1w1r_20x64_co____, stdcell_id, [(0,0,0.29,0.33)])
R(c_routeb_new_1w1r_20x64_co____, boundary, [(0,0,0.29,0.33)])

c_routeb_new_1w1r_20x64_co_____ = lib.new_cell('routeb_new_1w1r_20x64_contact_18')
R(c_routeb_new_1w1r_20x64_co_____, met1, [(0,0.03,0.32,0.29)])
R(c_routeb_new_1w1r_20x64_co_____, via, [(0.085,0.085,0.235,0.235)])
R(c_routeb_new_1w1r_20x64_co_____, met2, [(0.03,0,0.29,0.32)])
R(c_routeb_new_1w1r_20x64_co_____, stdcell_id, [(0,0,0.32,0.32)])
R(c_routeb_new_1w1r_20x64_co_____, boundary, [(0,0,0.32,0.32)])

c_routeb_new_1w1r_20x64_co______ = lib.new_cell('routeb_new_1w1r_20x64_contact_21')
R(c_routeb_new_1w1r_20x64_co______, met2, [(0.025,0,0.305,0.37)])
R(c_routeb_new_1w1r_20x64_co______, via2, [(0.065,0.085,0.265,0.285)])
R(c_routeb_new_1w1r_20x64_co______, met3, [(0,0.02,0.33,0.35)])
R(c_routeb_new_1w1r_20x64_co______, stdcell_id, [(0,0,0.33,0.37)])
R(c_routeb_new_1w1r_20x64_co______, boundary, [(0,0,0.33,0.37)])

c_routeb_new_1w1r_20x64_co_______ = lib.new_cell('routeb_new_1w1r_20x64_contact_22')
R(c_routeb_new_1w1r_20x64_co_______, met3, [(0,0.005,0.38,0.325)])
R(c_routeb_new_1w1r_20x64_co_______, via3, [(0.09,0.065,0.29,0.265)])
R(c_routeb_new_1w1r_20x64_co_______, met4, [(0.025,0,0.355,0.33)])
R(c_routeb_new_1w1r_20x64_co_______, stdcell_id, [(0,0,0.38,0.33)])
R(c_routeb_new_1w1r_20x64_co_______, boundary, [(0,0,0.38,0.33)])

routeb_new_1w1r_20x64_de = lib.new_cell('routeb_new_1w1r_20x64_delay_chain')
R(routeb_new_1w1r_20x64_de, li1, [(-0.315,3.26,0.405,3.43)])
R(routeb_new_1w1r_20x64_de, met1_5, [(7.695,59.835,7.835,59.975)])
A(routeb_new_1w1r_20x64_de, met1, 2.085, 3.215, 0.32, 0.26, 4, 2, 1.84, 7.45)
A(routeb_new_1w1r_20x64_de, met1, 2.085, 17.355, 0.32, 0.26, 4, 2, 1.84, 7.45)
A(routeb_new_1w1r_20x64_de, met1, 2.085, 31.495, 0.32, 0.26, 4, 2, 1.84, 7.45)
A(routeb_new_1w1r_20x64_de, met1, 2.085, 45.635, 0.32, 0.26, 4, 2, 1.84, 7.45)
A(routeb_new_1w1r_20x64_de, met1, 2.085, 59.775, 0.32, 0.26, 4, 1, 1.84, 0)
R(routeb_new_1w1r_20x64_de, met1, [(7.2,-0.13,7.52,0.13), (-0.475,3.215,-0.155,3.475), (0.245,3.215,0.565,3.475), (0.82,3.215,1.14,3.475), (1.68,6.94,2,7.2), (1.68,6.94,2,7.2), (0.245,10.665,0.565,10.925), (0.82,10.665,1.14,10.925), (7.2,14.01,7.52,14.27), (7.2,14.01,7.52,14.27), (0.245,17.355,0.565,17.615), (0.82,17.355,1.14,17.615), (1.68,21.08,2,21.34), (1.68,21.08,2,21.34), (0.245,24.805,0.565,25.065), (0.82,24.805,1.14,25.065), (7.2,28.15,7.52,28.41), (7.2,28.15,7.52,28.41), (0.245,31.495,0.565,31.755), (0.82,31.495,1.14,31.755), (1.68,35.22,2,35.48), (1.68,35.22,2,35.48), (0.245,38.945,0.565,39.205), (0.82,38.945,1.14,39.205), (7.2,42.29,7.52,42.55), (7.2,42.29,7.52,42.55), (0.245,45.635,0.565,45.895), (0.82,45.635,1.14,45.895), (1.68,49.36,2,49.62), (1.68,49.36,2,49.62), (0.245,53.085,0.565,53.345), (0.82,53.085,1.14,53.345), (7.2,56.43,7.52,56.69), (7.2,56.43,7.52,56.69), (0.245,59.775,0.565,60.035), (0.82,59.775,1.14,60.035), (7.695,59.835,7.835,59.975), (1.68,63.5,2,63.76)])
R(routeb_new_1w1r_20x64_de, met2_5, [(-0.385,3.275,-0.245,3.415)])
A(routeb_new_1w1r_20x64_de, met2, 2.105, 3.22, 0.28, 0.245, 4, 2, 1.84, 7.45)
A(routeb_new_1w1r_20x64_de, met2, 0.91, 3.345, 0.14, 3.725, 1, 4, 0, 14.14)
A(routeb_new_1w1r_20x64_de, met2, 0.335, 7, 0.14, 0.14, 1, 8, 0, 7.07)
A(routeb_new_1w1r_20x64_de, met2, 0.405, 7, 0.575, 0.14, 1, 8, 0, 7.07)
A(routeb_new_1w1r_20x64_de, met2, 0.91, 7, 0.14, 0.14, 1, 8, 0, 7.07)
A(routeb_new_1w1r_20x64_de, met2, 0.335, 7.07, 0.14, 3.725, 1, 4, 0, 14.14)
A(routeb_new_1w1r_20x64_de, met2, 0.91, 10.795, 0.14, 3.345, 1, 4, 0, 14.14)
A(routeb_new_1w1r_20x64_de, met2, 0.335, 14.14, 0.14, 3.345, 1, 4, 0, 14.14)
A(routeb_new_1w1r_20x64_de, met2, 2.105, 17.36, 0.28, 0.245, 4, 2, 1.84, 7.45)
A(routeb_new_1w1r_20x64_de, met2, 2.105, 31.5, 0.28, 0.245, 4, 2, 1.84, 7.45)
A(routeb_new_1w1r_20x64_de, met2, 2.105, 45.64, 0.28, 0.245, 4, 2, 1.84, 7.45)
A(routeb_new_1w1r_20x64_de, met2, 2.105, 59.78, 0.28, 0.245, 4, 1, 1.84, 0)
R(routeb_new_1w1r_20x64_de, met2, [(7.22,-0.12,7.5,0.125), (0.84,3.22,1.12,3.465), (-0.385,3.275,-0.245,3.415), (1.7,6.95,1.98,7.195), (1.7,6.95,1.98,7.195), (0.84,10.67,1.12,10.915), (7.22,14.02,7.5,14.265), (7.22,14.02,7.5,14.265), (0.84,17.36,1.12,17.605), (1.7,21.09,1.98,21.335), (1.7,21.09,1.98,21.335), (0.84,24.81,1.12,25.055), (7.22,28.16,7.5,28.405), (7.22,28.16,7.5,28.405), (0.84,31.5,1.12,31.745), (1.7,35.23,1.98,35.475), (1.7,35.23,1.98,35.475), (0.84,38.95,1.12,39.195), (7.22,42.3,7.5,42.545), (7.22,42.3,7.5,42.545), (0.84,45.64,1.12,45.885), (1.7,49.37,1.98,49.615), (1.7,49.37,1.98,49.615), (0.84,53.09,1.12,53.335), (7.22,56.44,7.5,56.685), (7.22,56.44,7.5,56.685), (0.84,59.78,1.12,60.025), (1.7,63.51,1.98,63.755)])
R(routeb_new_1w1r_20x64_de, met3, [(6.985,-0.16,7.735,0.16), (0.98,3.195,7.765,3.495), (1.465,6.91,2.215,7.23), (1.465,6.91,2.215,7.23), (0.98,10.645,7.765,10.945), (6.985,13.98,7.735,14.3), (6.985,13.98,7.735,14.3), (0.98,17.335,7.765,17.635), (1.465,21.05,2.215,21.37), (1.465,21.05,2.215,21.37), (0.98,24.785,7.765,25.085), (6.985,28.12,7.735,28.44), (6.985,28.12,7.735,28.44), (0.98,31.475,7.765,31.775), (1.465,35.19,2.215,35.51), (1.465,35.19,2.215,35.51), (0.98,38.925,7.765,39.225), (6.985,42.26,7.735,42.58), (6.985,42.26,7.735,42.58), (0.98,45.615,7.765,45.915), (1.465,49.33,2.215,49.65), (1.465,49.33,2.215,49.65), (0.98,53.065,7.765,53.365), (6.985,56.4,7.735,56.72), (6.985,56.4,7.735,56.72), (0.98,59.755,7.765,60.055), (1.465,63.47,2.215,63.79)])
R(routeb_new_1w1r_20x64_de, met4_5, [(7.195,-0.25,7.525,63.795), (1.675,-0.165,2.005,63.88)])
R(routeb_new_1w1r_20x64_de, met4, [(7.195,-0.25,7.525,63.795), (1.675,-0.165,2.005,63.88)])
R(routeb_new_1w1r_20x64_de, stdcell_id, [(0,0,9.2,63.63)])
R(routeb_new_1w1r_20x64_de, boundary, [(0,0,9.2,63.63)])
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,0)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,0)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,0)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,0)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,0)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,14.14), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,14.14), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,14.14), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,14.14), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,14.14), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,14.14)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,14.14)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,14.14)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,14.14)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,14.14)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,28.28), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,28.28), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,28.28), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,28.28), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,28.28), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,28.28)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,28.28)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,28.28)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,28.28)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,28.28)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,42.42), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,42.42), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,42.42), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,42.42), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,42.42), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,42.42)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,42.42)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,42.42)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,42.42)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,42.42)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,56.56), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,56.56), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,56.56), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,56.56), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,56.56), x_reflection=True))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (0,56.56)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (1.84,56.56)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (3.68,56.56)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (5.52,56.56)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(routeb_new_1w1r_20x64_pi, (7.36,56.56)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,3.18)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,3.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,3.16)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,3.18)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,3.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,3.16)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,3.18)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,3.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,3.16)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,3.18)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,3.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,3.16)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,3.18)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,3.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,3.18)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,3.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,3.16)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,10.63)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,10.635)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,10.61)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,10.63)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,10.635)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,10.61)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,10.63)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,10.635)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,10.61)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,10.63)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,10.635)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,10.61)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,10.63)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,10.635)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,10.63)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,10.635)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,10.61)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,17.32)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,17.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,17.3)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,17.32)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,17.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,17.3)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,17.32)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,17.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,17.3)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,17.32)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,17.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,17.3)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,17.32)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,17.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,17.32)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,17.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,17.3)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,24.77)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,24.775)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,24.75)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,24.77)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,24.775)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,24.75)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,24.77)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,24.775)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,24.75)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,24.77)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,24.775)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,24.75)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,24.77)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,24.775)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,24.77)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,24.775)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,24.75)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,31.46)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,31.465)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,31.44)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,31.46)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,31.465)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,31.44)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,31.46)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,31.465)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,31.44)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,31.46)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,31.465)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,31.44)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,31.46)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,31.465)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,31.46)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,31.465)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,31.44)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,38.91)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,38.915)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,38.89)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,38.91)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,38.915)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,38.89)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,38.91)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,38.915)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,38.89)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,38.91)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,38.915)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,38.89)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,38.91)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,38.915)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,38.91)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,38.915)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,38.89)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,45.6)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,45.605)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,45.58)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,45.6)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,45.605)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,45.58)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,45.6)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,45.605)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,45.58)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,45.6)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,45.605)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,45.58)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,45.6)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,45.605)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,45.6)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,45.605)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,45.58)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,53.05)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,53.055)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,53.03)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,53.05)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,53.055)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,53.03)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,53.05)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,53.055)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,53.03)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,53.05)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,53.055)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,53.03)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,53.05)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,53.055)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,53.05)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,53.055)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,53.03)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (2.1,59.74)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (2.085,59.745)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (2.08,59.72)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (3.94,59.74)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (3.925,59.745)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (3.92,59.72)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (5.78,59.74)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (5.765,59.745)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (5.76,59.72)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,59.74)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.605,59.745)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.6,59.72)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.26,59.74)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.245,59.745)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (0.835,59.74)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (0.82,59.745)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (0.815,59.72)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,6.905)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,6.91)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,6.885)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,6.905)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,6.905)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,6.91)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,6.885)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,6.905)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,21.045)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,21.05)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,21.025)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,21.045)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,21.045)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,21.05)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,21.025)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,21.045)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,35.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,35.19)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,35.165)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,35.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,35.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,35.19)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,35.165)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,35.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,49.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,49.33)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,49.305)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,49.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,49.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,49.33)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,49.305)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,49.325)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (1.695,63.465)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (1.68,63.47)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (1.675,63.445)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (1.65,63.465)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,-0.165)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,-0.16)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,-0.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,-0.165)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,13.975)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,13.98)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,13.955)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,13.975)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,13.975)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,13.98)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,13.955)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,13.975)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,28.115)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,28.12)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,28.095)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,28.115)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,28.115)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,28.12)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,28.095)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,28.115)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,42.255)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,42.26)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,42.235)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,42.255)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,42.255)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,42.26)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,42.235)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,42.255)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,56.395)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,56.4)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,56.375)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,56.395)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.215,56.395)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (7.2,56.4)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co______, (7.195,56.375)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_______, (7.17,56.395)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (-0.46,3.18)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co_____, (-0.475,3.185)))
routeb_new_1w1r_20x64_de.add(gdstk.Reference(c_routeb_new_1w1r_20x64_co____, (7.62,59.74)))
routeb_new_1w1r_20x64_de.add(gdstk.Label('vdd', (1.84,31.858), layer=71, texttype=5))
routeb_new_1w1r_20x64_de.add(gdstk.Label('gnd', (7.36,31.772), layer=71, texttype=5))
routeb_new_1w1r_20x64_de.add(gdstk.Label('in', (-0.315,3.345), layer=69, texttype=5))
routeb_new_1w1r_20x64_de.add(gdstk.Label('out', (7.765,59.905), layer=68, texttype=5))

lib.write_gds('routeb_new_1w1r_20x64_delay_chain.gds')
